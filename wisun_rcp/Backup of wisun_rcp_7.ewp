# IAR project Backup of wisun_rcp_7.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG28B322F1024IM48 SiliconLaboratories EFR32FG28B322F1024IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32FG28B322F1024IM48=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0; MBED_CONF_MBED_TRACE_ENABLE=1; MBED_CONF_NANOSTACK_CONFIGURATION=ws_router; MBED_TRACE_MAX_LEVEL=TRACE_ACTIVE_LEVEL_ALL; DEBUG_EFM_USER=1; HAVE_LFN=1; HAVE_LFN_PARENT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; config\rail; autogen; gecko_sdk_4.4.3\platform\Device\SiliconLabs\EFR32FG28\Include; gecko_sdk_4.4.3\platform\common\inc; gecko_sdk_4.4.3\platform\CMSIS\Core\Include; gecko_sdk_4.4.3\platform\CMSIS\RTOS2\Include; gecko_sdk_4.4.3\platform\service\device_init\inc; gecko_sdk_4.4.3\platform\emdrv\dmadrv\inc; gecko_sdk_4.4.3\platform\emdrv\common\inc; gecko_sdk_4.4.3\platform\emlib\inc; gecko_sdk_4.4.3\util\third_party\freertos\cmsis\Include; gecko_sdk_4.4.3\util\third_party\freertos\kernel\include; gecko_sdk_4.4.3\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; gecko_sdk_4.4.3\platform\service\iostream\inc; gecko_sdk_4.4.3\platform\security\sl_component\sl_mbedtls_support\config; gecko_sdk_4.4.3\platform\security\sl_component\sl_mbedtls_support\config\preset; gecko_sdk_4.4.3\platform\security\sl_component\sl_mbedtls_support\inc; gecko_sdk_4.4.3\util\third_party\mbedtls\include; gecko_sdk_4.4.3\util\third_party\mbedtls\library; gecko_sdk_4.4.3\platform\emdrv\nvm3\inc; gecko_sdk_4.4.3\platform\peripheral\inc; gecko_sdk_4.4.3\platform\security\sl_component\sl_psa_driver\inc; gecko_sdk_4.4.3\platform\radio\rail_lib\common; gecko_sdk_4.4.3\platform\radio\rail_lib\protocol\ble; gecko_sdk_4.4.3\platform\radio\rail_lib\protocol\ieee802154; gecko_sdk_4.4.3\platform\radio\rail_lib\protocol\wmbus; gecko_sdk_4.4.3\platform\radio\rail_lib\protocol\zwave; gecko_sdk_4.4.3\platform\radio\rail_lib\chip\efr32\efr32xg2x; gecko_sdk_4.4.3\platform\radio\rail_lib\protocol\sidewalk; gecko_sdk_4.4.3\platform\radio\rail_lib\plugin\pa-conversions; gecko_sdk_4.4.3\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28; gecko_sdk_4.4.3\platform\radio\rail_lib\plugin\rail_util_pti; gecko_sdk_4.4.3\platform\security\sl_component\se_manager\inc; gecko_sdk_4.4.3\platform\security\sl_component\se_manager\src; gecko_sdk_4.4.3\util\third_party\segger\systemview\SEGGER; gecko_sdk_4.4.3\util\silicon_labs\silabs_core\memory_manager; gecko_sdk_4.4.3\platform\common\toolchain\inc; gecko_sdk_4.4.3\platform\service\system\inc; gecko_sdk_4.4.3\app\wisun\component\ns_list; gecko_sdk_4.4.3\app\wisun\component\trace_util; gecko_sdk_4.4.3\app\wisun\component\trace_util\nanostack\nanostack-libservice\mbed-client-libservice; gecko_sdk_4.4.3\platform\service\sleeptimer\inc; gecko_sdk_4.4.3\protocol\wisun\stack\inc; gecko_sdk_4.4.3\protocol\wisun\app\wisun_rcp; gecko_sdk_4.4.3\protocol\wisun\stack\inc\socket; gecko_sdk_4.4.3\protocol\wisun\stack\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wisun_rcp_7.s37
  ILINK.IlinkOutputFile: wisun_rcp_7.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: wisun_rcp_7.ipcf
