# IAR project Backup of Wisun_Node_App.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG28B322F1024IM48 SiliconLaboratories EFR32FG28B322F1024IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; EFR32FG28B322F1024IM48=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\rail; config\wisun; .; gecko_sdk_4.4.5\platform\Device\SiliconLabs\EFR32FG28\Include; gecko_sdk_4.4.5\app\wisun\component\app_project_info; gecko_sdk_4.4.5\platform\common\inc; gecko_sdk_4.4.5\platform\service\cli\inc; gecko_sdk_4.4.5\platform\service\cli\src; gecko_sdk_4.4.5\platform\CMSIS\Core\Include; gecko_sdk_4.4.5\platform\CMSIS\RTOS2\Include; gecko_sdk_4.4.5\platform\service\device_init\inc; gecko_sdk_4.4.5\platform\emdrv\common\inc; gecko_sdk_4.4.5\platform\emlib\inc; gecko_sdk_4.4.5\platform\service\iostream\inc; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\config; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\config\preset; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\inc; gecko_sdk_4.4.5\util\third_party\mbedtls\include; gecko_sdk_4.4.5\util\third_party\mbedtls\library; gecko_sdk_4.4.5\platform\micrium_os\common\source; gecko_sdk_4.4.5\platform\micrium_os\common\include; gecko_sdk_4.4.5\platform\micrium_os\cpu\include; gecko_sdk_4.4.5\platform\micrium_os\ports\source; gecko_sdk_4.4.5\platform\micrium_os; gecko_sdk_4.4.5\platform\micrium_os\kernel\source; gecko_sdk_4.4.5\platform\micrium_os\kernel\include; gecko_sdk_4.4.5\platform\emdrv\nvm3\inc; gecko_sdk_4.4.5\platform\peripheral\inc; gecko_sdk_4.4.5\util\third_party\printf; gecko_sdk_4.4.5\util\third_party\printf\inc; gecko_sdk_4.4.5\platform\security\sl_component\sl_psa_driver\inc; gecko_sdk_4.4.5\platform\radio\rail_lib\common; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\ble; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\ieee802154; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\wmbus; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\zwave; gecko_sdk_4.4.5\platform\radio\rail_lib\chip\efr32\efr32xg2x; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\sidewalk; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\pa-conversions; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\rail_util_pti; gecko_sdk_4.4.5\platform\security\sl_component\se_manager\inc; gecko_sdk_4.4.5\platform\security\sl_component\se_manager\src; gecko_sdk_4.4.5\util\third_party\segger\systemview\SEGGER; gecko_sdk_4.4.5\util\silicon_labs\silabs_core\memory_manager; gecko_sdk_4.4.5\platform\common\toolchain\inc; gecko_sdk_4.4.5\platform\service\system\inc; gecko_sdk_4.4.5\app\wisun\component\app_core; gecko_sdk_4.4.5\app\wisun\component\app_setting; gecko_sdk_4.4.5\app\wisun\component\cli_util; gecko_sdk_4.4.5\app\wisun\component\event_manager; gecko_sdk_4.4.5\app\wisun\component\ns_list; gecko_sdk_4.4.5\app\wisun\component\ping; gecko_sdk_4.4.5\app\wisun\component\trace_util; gecko_sdk_4.4.5\app\wisun\component\trace_util\nanostack\nanostack-libservice\mbed-client-libservice; gecko_sdk_4.4.5\app\wisun\component\udp_client; gecko_sdk_4.4.5\platform\service\sleeptimer\inc; gecko_sdk_4.4.5\protocol\wisun\plugin; gecko_sdk_4.4.5\protocol\wisun\stack\inc; gecko_sdk_4.4.5\protocol\wisun\stack\inc\socket
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Wisun_Node_App.s37
  ILINK.IlinkOutputFile: Wisun_Node_App.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  ILINK.IlinkExtraOptions: --advanced_heap
  group (top)
    ./: Wisun_Node_App.ipcf
