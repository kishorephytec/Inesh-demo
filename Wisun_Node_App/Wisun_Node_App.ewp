# IAR project Wisun_Node_App.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG28B322F1024IM48 SiliconLaboratories EFR32FG28B322F1024IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; EFR32FG28B322F1024IM48=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; config\rail; config\wisun; .; gecko_sdk_4.4.5\platform\Device\SiliconLabs\EFR32FG28\Include; gecko_sdk_4.4.5\app\wisun\component\app_project_info; gecko_sdk_4.4.5\platform\common\inc; gecko_sdk_4.4.5\platform\service\cli\inc; gecko_sdk_4.4.5\platform\service\cli\src; gecko_sdk_4.4.5\platform\CMSIS\Core\Include; gecko_sdk_4.4.5\platform\CMSIS\RTOS2\Include; gecko_sdk_4.4.5\platform\service\device_init\inc; gecko_sdk_4.4.5\platform\emdrv\common\inc; gecko_sdk_4.4.5\platform\emlib\inc; gecko_sdk_4.4.5\platform\service\iostream\inc; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\config; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\config\preset; gecko_sdk_4.4.5\platform\security\sl_component\sl_mbedtls_support\inc; gecko_sdk_4.4.5\util\third_party\mbedtls\include; gecko_sdk_4.4.5\util\third_party\mbedtls\library; gecko_sdk_4.4.5\platform\micrium_os\common\source; gecko_sdk_4.4.5\platform\micrium_os\common\include; gecko_sdk_4.4.5\platform\micrium_os\cpu\include; gecko_sdk_4.4.5\platform\micrium_os\ports\source; gecko_sdk_4.4.5\platform\micrium_os; gecko_sdk_4.4.5\platform\micrium_os\kernel\source; gecko_sdk_4.4.5\platform\micrium_os\kernel\include; gecko_sdk_4.4.5\platform\emdrv\nvm3\inc; gecko_sdk_4.4.5\platform\peripheral\inc; gecko_sdk_4.4.5\util\third_party\printf; gecko_sdk_4.4.5\util\third_party\printf\inc; gecko_sdk_4.4.5\platform\security\sl_component\sl_psa_driver\inc; gecko_sdk_4.4.5\platform\radio\rail_lib\common; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\ble; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\ieee802154; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\wmbus; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\zwave; gecko_sdk_4.4.5\platform\radio\rail_lib\chip\efr32\efr32xg2x; gecko_sdk_4.4.5\platform\radio\rail_lib\protocol\sidewalk; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\pa-conversions; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28; gecko_sdk_4.4.5\platform\radio\rail_lib\plugin\rail_util_pti; gecko_sdk_4.4.5\platform\security\sl_component\se_manager\inc; gecko_sdk_4.4.5\platform\security\sl_component\se_manager\src; gecko_sdk_4.4.5\util\third_party\segger\systemview\SEGGER; gecko_sdk_4.4.5\util\silicon_labs\silabs_core\memory_manager; gecko_sdk_4.4.5\platform\common\toolchain\inc; gecko_sdk_4.4.5\platform\service\system\inc; gecko_sdk_4.4.5\app\wisun\component\app_core; gecko_sdk_4.4.5\app\wisun\component\app_setting; gecko_sdk_4.4.5\app\wisun\component\cli_util; gecko_sdk_4.4.5\app\wisun\component\event_manager; gecko_sdk_4.4.5\app\wisun\component\ns_list; gecko_sdk_4.4.5\app\wisun\component\ping; gecko_sdk_4.4.5\app\wisun\component\trace_util; gecko_sdk_4.4.5\app\wisun\component\trace_util\nanostack\nanostack-libservice\mbed-client-libservice; gecko_sdk_4.4.5\app\wisun\component\udp_client; gecko_sdk_4.4.5\platform\service\sleeptimer\inc; gecko_sdk_4.4.5\protocol\wisun\plugin; gecko_sdk_4.4.5\protocol\wisun\stack\inc; gecko_sdk_4.4.5\protocol\wisun\stack\inc\socket; autogen
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Wisun_Node_App.s37
  ILINK.IlinkOutputFile: Wisun_Node_App.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  ILINK.IlinkExtraOptions: --advanced_heap
  group (top)
    ./: Wisun_Node_App.ipcf
  group Simplicity Configurator
    ./: app.c app.h app_init.c app_init.h main.c readme.md readme_img0.png readme_img1.png uart_hal.c uart_hal.h uart_udp_com.c uart_udp_com.h
  group Simplicity Configurator/autogen
    autogen/: .crc_config.crc linkerfile.icf radioconf_generation_log.json rail_config.c rail_config.h RTE_Components.h rtos_description.h sl_cli_command_table.c sl_cli_handles.h sl_cli_instances.c sl_cli_instances.h sl_component_catalog.h sl_device_init_clocks.c sl_event_handler.c sl_event_handler.h sl_iostream_handles.c sl_iostream_handles.h sl_iostream_init_instances.h sl_wisun_config.c sl_wisun_config.h sli_cli_hooks.c sli_mbedtls_config_autogen.h sli_mbedtls_config_transform_autogen.h sli_psa_builtin_config_autogen.h sli_psa_config_autogen.h
  group Simplicity Configurator/config
    config/: app_project_info_config.h common_cfg.h cpu_cfg.h emlib_core_debug_config.h nvm3_default_config.h os_cfg.h psa_crypto_config.h rtos_cfg.h rtos_err_cfg.h SEGGER_RTT_Conf.h sl_device_init_dcdc_config.h sl_device_init_emu_config.h sl_device_init_hfxo_config.h sl_mbedtls_config.h sl_mbedtls_device_config.h sl_memory_config.h sl_rail_util_pa_config.h sl_rail_util_pti_config.h sl_sleeptimer_config.h sl_wisun_app_core_config.h
  group Simplicity Configurator/config/rail
    config/rail/: profile_wisun_fan_1_0.restriction profile_wisun_fan_1_1.restriction profile_wisun_han.restriction radio_settings.radioconf
  group Simplicity Configurator/config/wisun
    config/wisun/: lfn_not_supported.restriction wisun_settings.wisunconf
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/app_core
    gecko_sdk_4.4.5/app/wisun/component/app_core/: sl_wisun_app_core.c sl_wisun_app_core.h sl_wisun_app_core_util.c sl_wisun_app_core_util.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/app_project_info
    gecko_sdk_4.4.5/app/wisun/component/app_project_info/: app_project_info.c app_project_info.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/app_setting
    gecko_sdk_4.4.5/app/wisun/component/app_setting/: sl_wisun_app_setting.c sl_wisun_app_setting.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/cli_util
    gecko_sdk_4.4.5/app/wisun/component/cli_util/: sl_wisun_cli_core.c sl_wisun_cli_core.h sl_wisun_cli_settings.c sl_wisun_cli_settings.h sl_wisun_cli_util.c sl_wisun_cli_util.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/event_manager
    gecko_sdk_4.4.5/app/wisun/component/event_manager/: sl_wisun_event_mgr.c sl_wisun_event_mgr.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/ns_list
    gecko_sdk_4.4.5/app/wisun/component/ns_list/: ns_list.c ns_list.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/trace_util
    gecko_sdk_4.4.5/app/wisun/component/trace_util/: sl_wisun_ip6string.h sl_wisun_trace_util.c sl_wisun_trace_util.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/mbed-client-libservice
    gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/mbed-client-libservice/: common_functions.h common_inlined_functions.h ip6string.h ns_types.h
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/source/libBits
    gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/source/libBits/: common_functions.c common_inlined_functions.c
  group Simplicity Configurator/gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/source/libip6string
    gecko_sdk_4.4.5/app/wisun/component/trace_util/nanostack/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/CMSIS/Core/Include
    gecko_sdk_4.4.5/platform/CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/CMSIS/RTOS2/Include
    gecko_sdk_4.4.5/platform/CMSIS/RTOS2/Include/: cmsis_os2.h os_tick.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/CMSIS/RTOS2/Source
    gecko_sdk_4.4.5/platform/CMSIS/RTOS2/Source/: os_systick.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/common/inc
    gecko_sdk_4.4.5/platform/common/inc/: sl_assert.h sl_atomic.h sl_cmsis_os2_common.h sl_common.h sl_enum.h sl_slist.h sl_status.h sl_string.h sli_cmsis_os2_ext_task_register.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/common/src
    gecko_sdk_4.4.5/platform/common/src/: sl_assert.c sl_slist.c sl_string.c sli_cmsis_os2_ext_task_register.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/common/toolchain/inc
    gecko_sdk_4.4.5/platform/common/toolchain/inc/: sl_memory.h sl_memory_region.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/common/toolchain/src
    gecko_sdk_4.4.5/platform/common/toolchain/src/: sl_memory.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/Device/SiliconLabs/EFR32FG28/Include
    gecko_sdk_4.4.5/platform/Device/SiliconLabs/EFR32FG28/Include/: efr32fg28_acmp.h efr32fg28_aes.h efr32fg28_buram.h efr32fg28_burtc.h efr32fg28_cmu.h efr32fg28_dcdc.h efr32fg28_devinfo.h efr32fg28_dma_descriptor.h efr32fg28_dpll.h efr32fg28_emu.h efr32fg28_eusart.h efr32fg28_fsrco.h efr32fg28_gpcrc.h efr32fg28_gpio.h efr32fg28_gpio_port.h efr32fg28_hfrco.h efr32fg28_hfxo.h efr32fg28_i2c.h efr32fg28_iadc.h efr32fg28_icache.h efr32fg28_keyscan.h efr32fg28_lcd.h efr32fg28_lcdrf.h efr32fg28_ldma.h efr32fg28_ldmaxbar.h efr32fg28_ldmaxbar_defines.h efr32fg28_lesense.h efr32fg28_letimer.h efr32fg28_lfrco.h efr32fg28_lfxo.h efr32fg28_mailbox.h efr32fg28_mpahbram.h efr32fg28_msc.h efr32fg28_mvp.h efr32fg28_pcnt.h efr32fg28_pfmxpprf.h efr32fg28_prs.h efr32fg28_prs_signals.h efr32fg28_scratchpad.h efr32fg28_semailbox.h efr32fg28_smu.h efr32fg28_syscfg.h efr32fg28_sysrtc.h efr32fg28_timer.h efr32fg28_ulfrco.h efr32fg28_usart.h efr32fg28_vdac.h efr32fg28_wdog.h efr32fg28b322f1024im48.h em_device.h system_efr32fg28.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/Device/SiliconLabs/EFR32FG28/Source
    gecko_sdk_4.4.5/platform/Device/SiliconLabs/EFR32FG28/Source/: startup_efr32fg28.c system_efr32fg28.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emdrv/common/inc
    gecko_sdk_4.4.5/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emdrv/nvm3/inc
    gecko_sdk_4.4.5/platform/emdrv/nvm3/inc/: nvm3.h nvm3_default.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emdrv/nvm3/lib
    gecko_sdk_4.4.5/platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emdrv/nvm3/src
    gecko_sdk_4.4.5/platform/emdrv/nvm3/src/: nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emlib/inc
    gecko_sdk_4.4.5/platform/emlib/inc/: em_assert.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_core_generic.h em_emu.h em_gpio.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_se.h em_syscfg.h em_system.h em_system_generic.h em_timer.h em_usart.h em_version.h sli_em_cmu.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/emlib/src
    gecko_sdk_4.4.5/platform/emlib/src/: em_burtc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_msc.c em_prs.c em_se.c em_system.c em_timer.c em_usart.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/include
    gecko_sdk_4.4.5/platform/micrium_os/common/include/: common.h kal.h lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h lib_utils.h logging.h platform_mgr.h rtos_err.h rtos_opt_def.h rtos_path.h rtos_prio.h rtos_types.h rtos_utils.h rtos_version.h toolchains.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/collections
    gecko_sdk_4.4.5/platform/micrium_os/common/source/collections/: bitmap.c bitmap_priv.h map.c map_priv.h slist.c slist_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/common
    gecko_sdk_4.4.5/platform/micrium_os/common/source/common/: common.c common_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/kal
    gecko_sdk_4.4.5/platform/micrium_os/common/source/kal/: kal_kernel.c kal_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/lib
    gecko_sdk_4.4.5/platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_str_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/logging
    gecko_sdk_4.4.5/platform/micrium_os/common/source/logging/: logging.c logging_chk_priv.h logging_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/platform_mgr
    gecko_sdk_4.4.5/platform/micrium_os/common/source/platform_mgr/: platform_mgr.c platform_mgr_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/preprocessor
    gecko_sdk_4.4.5/platform/micrium_os/common/source/preprocessor/: preprocessor_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/ring_buf
    gecko_sdk_4.4.5/platform/micrium_os/common/source/ring_buf/: ring_buf.c ring_buf_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/common/source/rtos
    gecko_sdk_4.4.5/platform/micrium_os/common/source/rtos/: rtos_err_str.c rtos_utils.c rtos_utils_priv.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/cpu/include
    gecko_sdk_4.4.5/platform/micrium_os/cpu/include/: cpu.h cpu_cache.h cpu_def.h cpu_port_sel.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/cpu/source
    gecko_sdk_4.4.5/platform/micrium_os/cpu/source/: cpu_core.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/kernel/include
    gecko_sdk_4.4.5/platform/micrium_os/kernel/include/: os.h os_port_sel.h os_trace.h os_type.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/kernel/source
    gecko_sdk_4.4.5/platform/micrium_os/kernel/source/: cmsis_os2.c os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mon.c os_msg.c os_mutex.c os_prio.c os_priv.h os_q.c os_sem.c os_stat.c os_task.c os_time.c os_tmr.c os_var.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/ports/source/generic
    gecko_sdk_4.4.5/platform/micrium_os/ports/source/generic/: arm_cpu_dwt_ts.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/micrium_os/ports/source/iar
    gecko_sdk_4.4.5/platform/micrium_os/ports/source/iar/: armv7m_cpu_c.c armv7m_cpu_port.h armv7m_os_cpu.h armv7m_os_cpu_c.c armv8m_cpu_a.asm armv8m_os_cpu_a.asm
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/peripheral/inc
    gecko_sdk_4.4.5/platform/peripheral/inc/: peripheral_sysrtc.h peripheral_sysrtc_compat.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/peripheral/src
    gecko_sdk_4.4.5/platform/peripheral/src/: peripheral_sysrtc.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/autogen/librail_release
    gecko_sdk_4.4.5/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg28_iar_release.a
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/chip/efr32/efr32xg2x
    gecko_sdk_4.4.5/platform/radio/rail_lib/chip/efr32/efr32xg2x/: rail_chip_specific.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/common
    gecko_sdk_4.4.5/platform/radio/rail_lib/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/pa-conversions
    gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_conversions_efr32.h pa_curve_types_efr32.h pa_curves_efr32.c pa_curves_efr32.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/pa-conversions/efr32xg28
    gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/pa-conversions/efr32xg28/: sl_rail_util_pa_curves_14dbm_868M.h sl_rail_util_pa_curves_14dbm_915M.h sl_rail_util_pa_curves_20dbm_868M.h sl_rail_util_pa_curves_20dbm_915M.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/rail_util_pti
    gecko_sdk_4.4.5/platform/radio/rail_lib/plugin/rail_util_pti/: sl_rail_util_pti.c sl_rail_util_pti.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/ble
    gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/ble/: rail_ble.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/ieee802154
    gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/ieee802154/: rail_ieee802154.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/sidewalk
    gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/sidewalk/: rail_sidewalk.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/wmbus
    gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/wmbus/: rail_wmbus.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/zwave
    gecko_sdk_4.4.5/platform/radio/rail_lib/protocol/zwave/: rail_zwave.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/se_manager/inc
    gecko_sdk_4.4.5/platform/security/sl_component/se_manager/inc/: sl_se_manager.h sl_se_manager_attestation.h sl_se_manager_check_config.h sl_se_manager_cipher.h sl_se_manager_config.h sl_se_manager_defines.h sl_se_manager_entropy.h sl_se_manager_hash.h sl_se_manager_internal_keys.h sl_se_manager_key_derivation.h sl_se_manager_key_handling.h sl_se_manager_signature.h sl_se_manager_types.h sl_se_manager_util.h sli_se_manager_features.h sli_se_manager_internal.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/se_manager/src
    gecko_sdk_4.4.5/platform/security/sl_component/se_manager/src/: sl_se_manager.c sl_se_manager_attestation.c sl_se_manager_cipher.c sl_se_manager_entropy.c sl_se_manager_hash.c sl_se_manager_key_derivation.c sl_se_manager_key_handling.c sl_se_manager_signature.c sl_se_manager_util.c sli_se_manager_osal.h sli_se_manager_osal_cmsis_rtos2.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/config
    gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/config/: sli_mbedtls_acceleration.h sli_mbedtls_omnipresent.h sli_psa_acceleration.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/inc
    gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/inc/: aes_alt.h ccm_alt.h cmac_alt.h ecjpake_alt.h gcm_alt.h se_management.h sha1_alt.h sha256_alt.h sha512_alt.h sl_mbedtls.h sl_psa_crypto.h sl_psa_values.h sli_psa_crypto.h threading_alt.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/src
    gecko_sdk_4.4.5/platform/security/sl_component/sl_mbedtls_support/src/: mbedtls_ccm.c mbedtls_ecdsa_ecdh.c mbedtls_sha.c se_aes.c sl_entropy_hardware.c sl_mbedtls.c sl_psa_crypto.c sli_psa_crypto.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/inc
    gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/inc/: sli_psa_driver_common.h sli_psa_driver_features.h sli_se_driver_aead.h sli_se_driver_cipher.h sli_se_driver_key_derivation.h sli_se_driver_key_management.h sli_se_driver_mac.h sli_se_opaque_functions.h sli_se_opaque_types.h sli_se_transparent_functions.h sli_se_transparent_types.h sli_se_version_dependencies.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/inc/psa
    gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/inc/psa/: error.h internal_trusted_storage.h sli_internal_trusted_storage.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/src
    gecko_sdk_4.4.5/platform/security/sl_component/sl_psa_driver/src/: sl_psa_its_nvm3.c sli_psa_driver_common.c sli_psa_driver_init.c sli_psa_trng.c sli_se_driver_aead.c sli_se_driver_builtin_keys.c sli_se_driver_cipher.c sli_se_driver_key_derivation.c sli_se_driver_key_management.c sli_se_driver_mac.c sli_se_driver_signature.c sli_se_opaque_driver_aead.c sli_se_opaque_driver_cipher.c sli_se_opaque_driver_mac.c sli_se_opaque_key_derivation.c sli_se_transparent_driver_aead.c sli_se_transparent_driver_cipher.c sli_se_transparent_driver_hash.c sli_se_transparent_driver_mac.c sli_se_transparent_key_derivation.c sli_se_version_dependencies.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/device_init/inc
    gecko_sdk_4.4.5/platform/service/device_init/inc/: sl_device_init_clocks.h sl_device_init_dcdc.h sl_device_init_emu.h sl_device_init_hfxo.h sl_device_init_nvic.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/device_init/src
    gecko_sdk_4.4.5/platform/service/device_init/src/: sl_device_init_dcdc_s2.c sl_device_init_emu_s2.c sl_device_init_hfxo_s2.c sl_device_init_nvic.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/iostream/inc
    gecko_sdk_4.4.5/platform/service/iostream/inc/: sl_iostream.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/iostream/src
    gecko_sdk_4.4.5/platform/service/iostream/src/: sl_iostream.c sl_iostream_retarget_stdio.c
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/sleeptimer/inc
    gecko_sdk_4.4.5/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/sleeptimer/src
    gecko_sdk_4.4.5/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_burtc.c sl_sleeptimer_hal_sysrtc.c sl_sleeptimer_hal_timer.c sli_sleeptimer_hal.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/system/inc
    gecko_sdk_4.4.5/platform/service/system/inc/: sl_system_init.h sl_system_kernel.h
  group Simplicity Configurator/gecko_sdk_4.4.5/platform/service/system/src
    gecko_sdk_4.4.5/platform/service/system/src/: sl_system_init.c sl_system_kernel.c
  group Simplicity Configurator/gecko_sdk_4.4.5/protocol/wisun
    gecko_sdk_4.4.5/protocol/wisun/: LICENSE
  group Simplicity Configurator/gecko_sdk_4.4.5/protocol/wisun/plugin
    gecko_sdk_4.4.5/protocol/wisun/plugin/: sl_wisun_legacy_socket_wrapper.c sl_wisun_legacy_socket_wrapper.h
  group Simplicity Configurator/gecko_sdk_4.4.5/protocol/wisun/stack
    gecko_sdk_4.4.5/protocol/wisun/stack/: libwisun_router_core_efr32xg2x_iar_debug.a
  group Simplicity Configurator/gecko_sdk_4.4.5/protocol/wisun/stack/inc
    gecko_sdk_4.4.5/protocol/wisun/stack/inc/: sl_wisun_api.h sl_wisun_common.h sl_wisun_connection_params_api.h sl_wisun_events.h sl_wisun_lfn_params_api.h sl_wisun_stack.h sl_wisun_trace_api.h sl_wisun_types.h sl_wisun_version.h sli_wisun_internal_api.h sli_wisun_timer_service.h
  group Simplicity Configurator/gecko_sdk_4.4.5/protocol/wisun/stack/inc/socket
    gecko_sdk_4.4.5/protocol/wisun/stack/inc/socket/: socket.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/silicon_labs/silabs_core/memory_manager
    gecko_sdk_4.4.5/util/silicon_labs/silabs_core/memory_manager/: sl_malloc.c sl_malloc.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/mbedtls/include/mbedtls
    gecko_sdk_4.4.5/util/third_party/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/mbedtls/include/psa
    gecko_sdk_4.4.5/util/third_party/mbedtls/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/mbedtls/library
    gecko_sdk_4.4.5/util/third_party/mbedtls/library/: aes.c alignment.h asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.c bignum_core.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h bn_mul.h ccm.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h hmac_drbg.c lmots.h md.c md_psa.h md_wrap.h mps_common.h mps_error.h mps_reader.h mps_trace.h nist_kw.c oid.c padlock.h pem.c pk.c pk_internal.h pk_wrap.c pk_wrap.h pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_util.c psa_util_internal.h rsa_alt_helpers.h sha1.c sha256.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_invasive.h ssl_tls13_keys.h threading.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/printf
    gecko_sdk_4.4.5/util/third_party/printf/: printf.c printf.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/printf/inc
    gecko_sdk_4.4.5/util/third_party/printf/inc/: iostream_printf.h
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/printf/src
    gecko_sdk_4.4.5/util/third_party/printf/src/: iostream_printf.c
  group Simplicity Configurator/gecko_sdk_4.4.5/util/third_party/segger/systemview/SEGGER
    gecko_sdk_4.4.5/util/third_party/segger/systemview/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h
